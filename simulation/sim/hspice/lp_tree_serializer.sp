*djsklfei
.HDL "lp_tree_serializer_final.v"
.HDL "../src/libs.ref/sky130_fd_io/verilog/sky130_ef_io.v"
.HDL "../src/libs.ref/sky130_fd_io/verilog/sky130_fd_io.v"
.HDL "../src/libs.ref/sky130_fd_sc_hd/verilog/primitives.v"
.HDL "../src/libs.ref/sky130_fd_sc_hd/verilog/sky130_fd_sc_hd.v"
.HDL "../src/libs.ref/sky130_fd_sc_hvl/verilog/primitives.v"
.HDL "../src/libs.ref/sky130_fd_sc_hvl/verilog/sky130_fd_sc_hvl.v"
.HDL "../src/libs.ref/sky130_sram_macros/verilog/sky130_sram_1kbyte_1rw1r_32x256_8.v"
.HDL "../src/libs.ref/sky130_sram_macros/verilog/sky130_sram_1kbyte_1rw1r_8x1024_8.v"
.HDL "../src/libs.ref/sky130_sram_macros/verilog/sky130_sram_2kbyte_1rw1r_32x512_8.v"
.HDL "../src/libs.ref/sky130_sram_macros/verilog/sram_1rw1r_32_256_8_sky130.v"

*dut CLK RESET SERIAL_OUT PAR_IN lp_tree_serializer
dut CLK RESET lp_tree_serializer_final
